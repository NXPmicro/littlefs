## Kconfig
```kconfig
menuconfig MCUX_COMPONENT_middleware.littlefs
    bool "LittleFS"
    default n
    help
        This option will enable LittleFS Middleware component
```
